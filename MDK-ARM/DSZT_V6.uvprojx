# Keil uVision project DSZT_V6.uvprojx, settings and files
target DSZT_V6 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: DSZT_V6 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F427xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../application;../application/command;../application/chassis;../application/lighting;../application/buzzer;../application/debug;../bsp/communication;../bsp/dispatch;../bsp/buzzer;../modules/protocol;../modules/drive;../modules/remote;../modules/lighting;../modules/input;../modules/steering;../modules/encoder;../modules/algorithm
  asm include: ../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f427xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group V6/Application
    ../application/: robot.c vehicle_status.h
    ../application/command/: command_app.c
    ../application/chassis/: chassis_app.c
    ../application/lighting/: lighting_app.c
    ../application/buzzer/: buzzer_app.c
    ../application/debug/: debug_app.c
  group V6/Config
    ../application/chassis/: chassis_config.h
    ../application/command/: command_config.h
    ../application/debug/: debug_config.h
    ../application/lighting/: lighting_config.h
    ../application/buzzer/: buzzer_config.h
  group V6/BSP
    ../bsp/dispatch/: bsp_callback.c
    ../bsp/communication/: bsp_uart.c bsp_rs485.c
    ../bsp/buzzer/: bsp_buzzer.c
  group V6/Modules
    ../application/chassis/: dual_steer.c
    ../modules/steering/: steer_motor.c
    ../modules/encoder/: mt6826s_pwm.c
    ../modules/algorithm/: steer_angle_ctrl.c
    ../modules/protocol/: modbus_rtu.c
    ../modules/drive/: oid_esc.c front_drive.c
    ../modules/remote/: sbus_rc.c
    ../modules/lighting/: ws2812_strip.c
    ../modules/input/: pwm_input.c
software components: CMSIS:CORE 4.3.0
